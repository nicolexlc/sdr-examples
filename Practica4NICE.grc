options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blks2_selector_0
  id: blks2_selector
  parameters:
    input_index: variable_chooser_0
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: '1'
  states: {}
- name: blks2_tcp_sink_0
  id: blks2_tcp_sink
  parameters:
    addr: 127.0.0.1
    port: '9999'
    server: 'False'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\nicko\Downloads\Energetic Rock (30 sec) - Royalty-Free Background Music _ Cinematic.wav
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '10000'
    decim: '1'
    samp_rate: samp_rate
    taps: '4'
    type: ccc
  states: {}
- name: variable_chooser_0
  id: variable_chooser
  parameters:
    choices: '[0,1]'
    grid_pos: 0,0,1,10
    label: ''
    labels: '[''tono'',''song'' ]'
    style: wx.RA_HORIZONTAL
    type: radio_buttons
    value: '1'
  states: {}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}

connections:
- [analog_nbfm_tx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blks2_selector_0, '0', analog_nbfm_tx_0, '0']
- [blocks_throttle_0, '0', blks2_selector_0, '0']
- [blocks_throttle_0_0, '0', blks2_selector_0, '1']
- [blocks_wavfile_source_0, '0', blocks_throttle_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blks2_tcp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', wxgui_fftsink2_0, '0']

metadata:
  file_format: 1
