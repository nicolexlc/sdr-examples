options:
  parameters:
    generate_options: qt_gui
    id: ReP1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fre
  id: variable
  parameters:
    value: 394e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label: '''D_AM'',''D_FM'''
    label0: AM
    label1: FM
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: '48000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '2000'
    audio_stop: '16000'
    chan_rate: '48000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: variable_qtgui_chooser_0
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '3'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: fre
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', audio_sink_0_0, '0']
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [blocks_selector_0, '0', analog_am_demod_cf_0, '0']
- [blocks_selector_0, '1', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
